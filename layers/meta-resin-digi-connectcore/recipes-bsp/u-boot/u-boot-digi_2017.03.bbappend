# Copyright (C) 2018 Digi International

UBOOT_KCONFIG_SUPPORT = "1"
inherit resin-u-boot
