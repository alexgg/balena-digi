PACKAGE_INSTALL_remove_ccimx6ul = " \
    initramfs-module-e2fs \
    initramfs-module-fsck \
    initramfs-module-resindataexpander \
"
