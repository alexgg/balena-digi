#INTERNAL_DEVICE_KERNEL_ccimx6ul = "TBD"
#INTERNAL_DEVICE_BOOTLOADER_CONFIG_ccimx6ul = "TBD"
#INTERNAL_DEVICE_BOOTLOADER_CONFIG_PATH_ccimx6ul = "TBD"
