RESIN_ROOT_FSTYPE = "hostapp-ubifs"
IMAGE_FSTYPES_ccimx6ul = "hostapp-ubifs boot.ubifs"

inherit image_types_resin_ubifs
